# Keil uVision project Scope_Final.uvprojx, settings and files
target Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.8.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Scope_Final +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: OS_STKCHECK
  c include: .\Listings;.\Listings\ADC;.\Listings\RTOS;.\Listings\DAC;.\Listings\SPI;.\Listings\Leds;.\Listings\Relays;.\Listings\Utils;.\Listings\Main
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Main
    ./Listings/Main/: main.c main.h
  group RTOS
    ./Listings/RTOS/: GUI_Thread.c Heart_Beat_Thread.c Acqusition_Thread.c Threads.h
  group Utils
    ./Listings/Utils/: Error_Handler.c Error_Handler.h
  group Leds
    ./Listings/Leds/: Leds.c Leds.h
  group Relays
    ./Listings/Relays/: Relays.c Relays.h
  group SPI
    ./Listings/SPI/: SPI_Config.c stm32f7xx_it.c stm32f7xx_it.h
  group DAC
    ./Listings/DAC/: DAC_Config.c DAC_Config.h
  group ADC
    ./Listings/ADC/: ADC_Config.c ADC_Config.h
  group VGA
    ./Listings/VGA/: VGA_Config.c VGA_Config.h
  group Documents
    ./: ReadMe.txt
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Buttons 1.1.1, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Touchscreen 1.1.1, Board Support:emWin LCD 1.1.1, Device:STM32Cube Framework:Classic 1.1.2, Device:STM32Cube HAL:Common 1.1.2, Device:STM32Cube HAL:Cortex 1.1.2, Device:STM32Cube HAL:DMA 1.1.2, Device:STM32Cube HAL:DMA2D 1.1.2, Device:STM32Cube HAL:GPIO 1.1.2, Device:STM32Cube HAL:I2C 1.1.2, Device:STM32Cube HAL:LTDC 1.1.2, Device:STM32Cube HAL:PWR 1.1.2, Device:STM32Cube HAL:RCC 1.1.2, Device:STM32Cube HAL:SDRAM 1.1.2, Device:STM32Cube HAL:SPI 1.1.2, Device:STM32Cube HAL:UART 1.1.2, Device:Startup 1.1.2, Graphics Display:STM32F746G-Discovery 1.0.0, Graphics:CORE 5.36.6, Graphics:Input Device:Touchscreen 5.36.6
